# Keil uVision project Smarthome.uvprojx, settings and files
target Smarthome (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smarthome +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_USB_OTG_FS
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\USART3;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\HARDWARE\SPBLCD;..\HARDWARE\I2S;..\HARDWARE\WM8978;..\HARDWARE\HC05;..\HARDWARE\SIM900A;..\HARDWARE\ETHERNET;..\MALLOC;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\PICTURE;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\APP;..\GUI;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\AUDIOCODEC\ape;..\AUDIOCODEC\ape\apedec;..\AUDIOCODEC\flac;..\AUDIOCODEC\flac\flacdec;..\AUDIOCODEC\mp3;..\AUDIOCODEC\mp3\helix;..\AUDIOCODEC\wav;..\MJPEG;..\MJPEG\JPEG;..\T9INPUT;..\ATKNCR;..\ATKFREC;..\HARDWARE\RS485;..\HARDWARE\BEEP;..\HARDWARE\CODETECT;..\HARDWARE\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SPBLCD/: spblcd.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c gt9147.c ft5206.c touch.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/ETHERNET/: stm32f4x7_eth.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/CODETECT/: codetect.c
    ../HARDWARE/MOTOR/: motor.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: spb.c common.c ebook.c audioplay.c lyric.c videoplay.c calendar.c settings.c notepad.c paint.c camera.c recorder.c appplay.c appplay_gyro.c appplay_frec.c bluetoothmanager.c smsplay.c picviewer.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group AUDIOCODEC_WAV
    ../AUDIOCODEC/wav/: wavplay.c
  group AUDIOCODEC_MP3
    ../AUDIOCODEC/mp3/: mp3play.c
    ../AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../AUDIOCODEC/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group AUDIOCODEC_FLAC
    ../AUDIOCODEC/flac/: flacplay.c
    ../AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
  group AUDIOCODEC_APE
    ../AUDIOCODEC/ape/: apeplay.c
    ../AUDIOCODEC/ape/apedec/: apedecoder.c entropy.c filter_16_11.c filter_32_10.c filter_64_11.c parser.c predictor.c predictor-arm.S
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_core.c usb_hcd.c usb_dcd_int.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_gamepad.c usbh_hid_keybd.c usbh_hid_mouse.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_storage_msd.c usbd_desc.c usbd_usr.c usbh_usr.c usb_app.c
  group MJPEG
    ../MJPEG/: avi.c mjpeg.c
    ../MJPEG/JPEG/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jidctint.c jdsample.c jdcolor.c jquant2.c jquant1.c jdmerge.c jmemnobs.c wrppm.c
  group T9INPUT
    ../T9INPUT/: t9input.c pyinput.c
  group ATKNCR
    ../ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group ATKFREC
    ../ATKFREC/: atk_frec.c ATKFREC.lib
  group README
    ../: Readme_STM32.txt
